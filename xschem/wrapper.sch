v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 320 -330 0 1 {name=p1 lab=reset}
C {devices/iopin.sym} 320 -360 0 1 {name=p2 lab=clk_in}
C {devices/iopin.sym} 320 -510 0 1 {name=l11 sig_type=std_logic lab=ref_in}
C {devices/iopin.sym} 320 -450 0 1 {name=l21 sig_type=std_logic lab=s_in}
C {devices/iopin.sym} 320 -420 0 1 {name=l22 sig_type=std_logic lab=load}
C {devices/iopin.sym} 320 -390 0 1 {name=l23 sig_type=std_logic lab=read}
C {devices/iopin.sym} 320 -480 0 1 {name=l26 sig_type=std_logic lab=s_out}
C {devices/iopin.sym} 490 -330 0 1 {name=l1 sig_type=std_logic lab=vb10}
C {devices/iopin.sym} 490 -350 0 1 {name=l2 sig_type=std_logic lab=vb11}
C {devices/iopin.sym} 490 -370 0 1 {name=l3 sig_type=std_logic lab=vb12}
C {devices/iopin.sym} 490 -390 0 1 {name=l4 sig_type=std_logic lab=vb13}
C {devices/iopin.sym} 490 -410 0 1 {name=l5 sig_type=std_logic lab=vb14}
C {devices/iopin.sym} 490 -430 0 1 {name=l6 sig_type=std_logic lab=vb15}
C {devices/iopin.sym} 490 -450 0 1 {name=l7 sig_type=std_logic lab=vb16}
C {devices/iopin.sym} 490 -470 0 1 {name=l8 sig_type=std_logic lab=vb17}
C {devices/iopin.sym} 600 -330 0 1 {name=l9 sig_type=std_logic lab=vb20}
C {devices/iopin.sym} 600 -350 0 1 {name=l10 sig_type=std_logic lab=vb21}
C {devices/iopin.sym} 600 -370 0 1 {name=l12 sig_type=std_logic lab=vb22
}
C {devices/iopin.sym} 600 -390 0 1 {name=l13 sig_type=std_logic lab=vb23}
C {devices/iopin.sym} 600 -410 0 1 {name=l14 sig_type=std_logic lab=vb24}
C {devices/iopin.sym} 600 -430 0 1 {name=l15 sig_type=std_logic lab=vb25}
C {devices/iopin.sym} 600 -450 0 1 {name=l16 sig_type=std_logic lab=vb26}
C {devices/iopin.sym} 600 -470 0 1 {name=l17 sig_type=std_logic lab=vb27}
C {devices/iopin.sym} 710 -330 0 1 {name=l18 sig_type=std_logic lab=vb30}
C {devices/iopin.sym} 710 -350 0 1 {name=l19 sig_type=std_logic lab=vb31}
C {devices/iopin.sym} 710 -370 0 1 {name=l20 sig_type=std_logic lab=vb32}
C {devices/iopin.sym} 710 -390 0 1 {name=l24 sig_type=std_logic lab=vb33}
C {devices/iopin.sym} 710 -410 0 1 {name=l25 sig_type=std_logic lab=vb34}
C {devices/iopin.sym} 710 -430 0 1 {name=l27 sig_type=std_logic lab=vb35}
C {devices/iopin.sym} 710 -450 0 1 {name=l28 sig_type=std_logic lab=vb36}
C {devices/iopin.sym} 710 -470 0 1 {name=l29 sig_type=std_logic lab=vb37}
C {devices/iopin.sym} 830 -330 0 1 {name=l30 sig_type=std_logic lab=dac0}
C {devices/iopin.sym} 830 -350 0 1 {name=l31 sig_type=std_logic lab=dac1}
C {devices/iopin.sym} 830 -370 0 1 {name=l32 sig_type=std_logic lab=dac2}
C {devices/iopin.sym} 830 -390 0 1 {name=l33 sig_type=std_logic lab=dac3}
C {devices/iopin.sym} 830 -410 0 1 {name=l34 sig_type=std_logic lab=dac4}
C {devices/iopin.sym} 830 -430 0 1 {name=l35 sig_type=std_logic lab=dac5}
C {devices/iopin.sym} 830 -450 0 1 {name=l36 sig_type=std_logic lab=dac6}
C {devices/iopin.sym} 830 -470 0 1 {name=l37 sig_type=std_logic lab=dac7}
C {devices/iopin.sym} 830 -490 0 1 {name=l38 sig_type=std_logic lab=dac8}
C {devices/iopin.sym} 830 -510 0 1 {name=l39 sig_type=std_logic lab=dac9}
C {devices/iopin.sym} 970 -330 0 1 {name=l40 sig_type=std_logic lab=slope0}
C {devices/iopin.sym} 970 -350 0 1 {name=l41 sig_type=std_logic lab=slope1}
C {devices/iopin.sym} 970 -370 0 1 {name=l42 sig_type=std_logic lab=slope2}
C {devices/iopin.sym} 970 -410 0 1 {name=l43 sig_type=std_logic lab=ff}
C {devices/iopin.sym} 970 -430 0 1 {name=l44 sig_type=std_logic lab=tt}
C {devices/iopin.sym} 970 -450 0 1 {name=l45 sig_type=std_logic lab=ss}
C {devices/iopin.sym} 970 -480 0 1 {name=l46 sig_type=std_logic lab=vco_in}
C {devices/iopin.sym} 970 -500 0 1 {name=l47 sig_type=std_logic lab=lock}
